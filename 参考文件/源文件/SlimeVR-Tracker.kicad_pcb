# Repository fuanxka/SlimeVR-Tracker

File README.md:

# SlimeVR-Tracker

## 声明
二次开发请注明原作者、出处并遵守相关开源协议。<br>
源PCB工程文件需使用Kicad5.99进行查看与编辑。<br>
**详细描述请看：https://sukimoe.net/projects/slimevr-tracker.html**

## 描述
目前SlimeVR的DIY方案为ESP8266/ESP32开发板+TP4056充电模块。这个方案存在一点问题，有点不够优雅：
- 开发板一般用的是MicroUSB接口，而充电模块用的是Type-C接口，如果需要更新固件你可能会满地找数据线。
- 两个接口不美观，且充电模块需要占用额外空间，导致DIY的成品会叠罗汉一样叠上三层。
- 锂电池直连3.3V引脚，而锂电池充满电的时电压为4.2V，具有一定风险。
- 没有合适的外壳，直接上身未免太极客了一点。

基于上述原因，诞生了这个项目，解决了上面的问题，并具有以下特点：
- 超小尺寸，超高集成度，仅比开发板长1mm。
- 整合接口，仅用一个Type-C接口实现充电与程序下载。
- 集成最最最重要的电池保护芯片。
- 预留电池引脚接口和开关引脚接口，锂电池不再直连3.3V引脚，而是会先经过降压芯片降压后输出。
- 智能切换供电，在有外部USB供电的情况下会切断锂电池供电并进行充电，断开供电后自动使用锂电池供电。
- 免驱哒！当连接电脑需要下载程序时，无需额外下载驱动，可直接识别通信。

### 规格尺寸
- PCB尺寸：25mm\*49mm\*1.6mm
- 外壳体积：53.2mm\*38mm\*21.6mm
- 传感器：BNO08X
- 电池：122530锂电池
- 开关：SS-12D07G3
- 导线：26AWG/28AWG
- 固定螺丝：6颗M2\*5
- 绑带：宽度3cm

### 电气参数
部分参数仅供参考，以实测为准。
锂电池充电电流不计算在负载内。
- USB供电电压：5V
- 工作电流：100mA
- 最大负载：500mA
- 充电电流：≤500mA
- 电池容量：1000mA
- 工作时间：约7-9小时

## 注意事项
**选型**
- TP4057芯片需选用`南京拓微`的，友台的数据手册部分数据有差异，可能会出现未知问题。
- 固定螺丝需要选用`薄头自攻螺丝`，头部直径≤4mm，头部厚度≤1mm。
- 传感器如BNO系列价格太高可选用MPU9250，但需要核对尺寸。

**焊接**
- 如果只有电烙铁可以不焊接CH9340K的底部EP焊盘，将不支持睡眠低功耗模式，详情请参阅该芯片数据手册。
- 因焊接工作量较大，建议使用锡膏和加热台进行铁板烧。

**烧录**
- 附件提供编译好的固件（编译自[SlimeVR-Tracker-ESP](https://github.com/SlimeVR/SlimeVR-Tracker-ESP)），也可自行下载编译。
- 请使用`ESP8266Flasher`进行程序烧录工作，波特率`115200`，`4Mbyte`，`40MHz`，`DIO`。

**使用**
- 使用时追踪器朝向需匹配固件配置，建议充电口朝下.有螺丝的那面朝自己。
- 如魔术贴比较硬，无弹性，建议无螺丝的一面朝自己，防止崩短穿孔，同时在软件中调整设置。
- 也可以选择不穿魔术贴，取一段单面的毛面魔术贴，粘贴到追踪器有螺丝的一面。

## 下载
> SlimeVR硬件：[SlimeVR-Tracker](https://github.com/FuAnMoe/SlimeVR-Tracker/archive/refs/heads/main.zip)

### SlimeVR软件/固件
> SlimeVR固件：[SlimeVR-Tracker-ESP](https://github.com/SlimeVR/SlimeVR-Tracker-ESP)<br>
> SlimeVR服务：[SlimeVR-Server](https://github.com/SlimeVR/SlimeVR-Server)<br>
> SlimeVR驱动：[SlimeVR-OpenVR-Driver](https://github.com/SlimeVR/SlimeVR-OpenVR-Driver)

## KiCad design 参考文件/源文件/SlimeVR-Tracker.kicad_pcb

Parts:
C1: 22uF; C_0603_1608Metric
C2: 10uF; C_0603_1608Metric
C3: 1uF; C_0603_1608Metric
C4, C7, C9: 100nF; C_0603_1608Metric
C5, C6: 4.7uF; C_0603_1608Metric
D1: 1N5819; D_SOD-323
J1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J2, J3: Conn_01x09_Male; PinHeader_1x09_P2.54mm_Vertical
LED1: RED; LED_0603_1608Metric
LED2: GREEN; LED_0603_1608Metric
Q1: CJ3401; SOT-23
Q2, Q3: S8050; SOT-23
R1, R2: 5K1; R_0603_1608Metric
R3: 1K66; R_0603_1608Metric
R4, R5: 1R; R_0603_1608Metric
R6, R7: 1K; R_0603_1608Metric
R8: 100R; R_0603_1608Metric
R9, R12, R13, R14, R15, R16: 10K; R_0603_1608Metric
R10, R11: 12K; R_0603_1608Metric
SW1: FLASH; SW_Push_SPST_NO_Alps_SKRK
SW2: RESET; SW_Push_SPST_NO_Alps_SKRK
U1: ESP-12E
U2: TP4057; TSOT-23-6
U3: DW06D; TSOT-23-6
U4: SPX3819M5-L-3-3; SOT-23-5
U5: CH9340K; ESSOP-10_3.9x4.9mm_P1.00mm_EP

Connections:
+3V3: C1.1, C6.1, C7.1, J2.2, J3.6, R12.1, R13.1, R14.1, R15.1, U1.8 (VCC), U4.5 (OUT), U5.7 (VCC), U5.10 (V3)
+5V: C3.2, D1.2 (A), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), J2.3, Q1.1 (G), R4.2, R6.1, R9.2
/BAT+: C2.1, J2.9, Q1.3 (D), R8.2, U2.3 (BAT)
/BAT-: C4.1, J2.8, U3.3 (S2), U3.6 (VSS)
/BOOT: J3.4, Q3.3 (C), R12.2, SW1.1, U1.18 (GPIO0)
/CC1: J1.A5 (CC1), R1.1
/CC2: J1.B5 (CC2), R2.1
/CHRG: LED1.1 (K), U2.1 (CHRG)
/D+: J1.A6 (D+), J1.B6 (D+), U5.1 (UD+)
/D-: J1.A7 (D-), J1.B7 (D-), U5.2 (UD-)
/DTR: Q3.2 (E), R10.2, U5.5 (DTR#)
/EN: J2.4, R14.2, U1.3 (EN)
/H_F: U5.0 (LOP#), U5.4 (H_F#)
/IO2: J3.5, R13.2, U1.17 (GPIO2)
/IO4: J3.3, U1.19 (GPIO4)
/IO5: J3.2, U1.20 (GPIO5)
/IO15: R16.2, U1.16 (GPIO15)
/IO16: J3.1, U1.4 (GPIO16)
/RST: C9.2, J2.5, Q2.3 (C), R15.2, SW2.1, U1.1 (~RST)
/RTS: Q2.2 (E), R11.2, U5.6 (RTS#)
/RXD: J3.8, U1.21 (GPIO3/RXD), U5.8 (TXD)
/STDBY: LED2.1 (K), U2.5 (STDBY)
/TXD: J3.9, U1.22 (GPIO1/TXD), U5.9 (RXD)
/VCC_SW0: D1.1 (K), J2.6, Q1.2 (S)
/VCC_SW1: C5.1, J2.7, U4.1 (IN), U4.3 (EN)
GND: C1.2, C3.1, C5.2, C6.2, C7.2, C9.1, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J2.1, J3.7, R1.2, R2.2, R3.2, R5.2, R7.1, R9.1, R16.1, SW1.2, SW2.2, U1.15 (GND), U2.2 (GND), U3.2 (S1), U4.2 (GND), U5.3 (GND)
unnamed: C2.2, R5.1
unnamed: C4.2, R8.1, U3.5 (VDD)
unnamed: LED1.2 (A), LED2.2 (A), R6.2
unnamed: Q2.1 (B), R10.1
unnamed: Q3.1 (B), R11.1
unnamed: R3.1, U2.6 (PROG)
unnamed: R4.1, U2.4 (VCC)
unnamed: R7.2, U3.1 (V-)

Notes on the sheet:
ESP8266主控
TYPE-C接口
电池充电模块
3.3V稳压 / 双电源切换
USB转TTL
电池保护模块
初始化 / Reset / Flash
IO引脚 只保留必要引脚
GND
3V3
RST
SW0
SW1
BAT-
BAT+
自动下崽
RXD
TXD

Board: 2 copper layers, 49.0 x 25.0 mm, 40 parts (0 on the bottom side), 34 nets.

## Commit log

2021-11-15 delete
2021-11-20 update firmware
